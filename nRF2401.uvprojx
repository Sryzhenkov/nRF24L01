# Keil uVision project nRF2401.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nRF2401 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wno-gnu-zero-variadic-macro-arguments
  c include: .\Module;.\Module\SYSTEM;.\Module\LED;.\Module\UART;.\Module\SPI;.\Module\NRF24;.\Module\TIMER;.\Module\NVIC;..\nRF24L01
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c GlobalSettings.h
  group module
    ./Module/System/: System.c
    ./Module/UART/: Uart.c
    ./Module/SPI/: spi.c
    ./Module/NRF24/: nRF24.c
    ./Module/TIMER/: Timer.c SysTick.c
    ./Module/NVIC/: NVIC.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
